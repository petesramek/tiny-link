#include <unity.h>
#include <vector>
#include <stdint.h>
#include <cmath>
#include <cstring>
#include <algorithm>
#include "support/stubs/globals.h"

struct OtherStruct { uint64_t raw; } __attribute__((packed));

/**
 * @brief TEST: End-to-end success.
 * Verifies Send -> COBS Encode -> Decode -> Verify Fletcher-16.
 */

void test_cobs_loopback(void) {
    TestPayload data = { 98765, 3.1415f };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);

    while(adapter.available() > 0 && !link.available()) {
        link.update();
    }

    TEST_ASSERT_TRUE(link.available());
    TEST_ASSERT_EQUAL_UINT32(data.uptime, link.peek().uptime);
    TEST_ASSERT_FLOAT_WITHIN(0.0001f, data.value, link.peek().value);
}

/**
 * @brief TEST: COBS transparency.
 * Verifies that a payload consisting entirely of 0x00 is handled correctly.
 */

void test_cobs_zero_payload(void) {
    TestPayload zeros = { 0, 0.0f };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), zeros);

    while(adapter.available() > 0 && !link.available()) {
        link.update();
    }
    TEST_ASSERT_TRUE_MESSAGE(link.available(), "COBS failed to handle all-zero payload");
}

/**
 * @brief TEST: Message Type Filtering.
 * Verifies that the engine handles valid packets of various Message Types.
 */

void test_type_filtering(void) {
    TestPayload data = { 55, 5.5f };
    link.sendData('A', data);

    while(adapter.available() > 0 && !link.available()) link.update();

    TEST_ASSERT_EQUAL_UINT8('A', link.type());
}

/**
 * @brief TEST: Floating Point Extremes.
 * Verifies that the protocol is bit-transparent and can handle Non-Finite
 * values (NAN/INF) often generated by failing sensors.
 */

void test_float_extremes(void) {
    TestPayload data = { 100, NAN };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);

    while(adapter.available() > 0 && !link.available()) {
        link.update();
    }

    TEST_ASSERT_TRUE(std::isnan(link.peek().value));
}

/**
 * @struct TinyStruct
 * @brief 1-byte structure to test the absolute lower limit of the protocol.
 */
struct TinyStruct {
    uint8_t val;
} __attribute__((packed));

/**
 * @brief TEST: Minimum Payload Handling.
 * Verifies that the protocol correctly encapsulates, encodes, and decodes
 * a single-byte payload. This ensures the COBS pointer logic and
 * Fletcher-16 bounds are scale-invariant.
 *
 * @pre A 1-byte struct is initialized.
 * @post The byte must be received perfectly after loopback.
 */

void test_minimum_payload(void) {
    // Create a specific link for the 1-byte struct
    tinylink::TinyLink<TinyStruct, LoopbackAdapter> tinyLink(adapter);
    TinyStruct s = { 0xFE };

    tinyLink.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), s);

    while(adapter.available() > 0 && !tinyLink.available()) {
        tinyLink.update();
    }

    TEST_ASSERT_TRUE(tinyLink.available());
    TEST_ASSERT_EQUAL_UINT8(0xFE, tinyLink.peek().val);
}

/** @test Verifies that valid packets with matching sizes but different purposes are distinguished by 'type()' */

void test_type_validation(void) {
    tinylink::TinyLink<OtherStruct, LoopbackAdapter> otherLink(adapter);
    OtherStruct data = { 0xDEADBEEF };

    otherLink.sendData('X', data); // Type 'X'
    while(adapter.available() > 0) otherLink.update();

    // The engine MUST report type 'X', allowing the user to reject it
    TEST_ASSERT_EQUAL_UINT8('X', otherLink.type());
}

/** @test Verifies that a zero at the very first byte of the payload is encoded/decoded correctly */

void test_leading_zero_payload(void) {
    TestPayload data = { 0x00FFFFFF, 1.0f }; // Leading zero in the uint32
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);
    while(adapter.available() > 0) link.update();
    TEST_ASSERT_EQUAL_UINT32(0x00FFFFFF, link.peek().uptime);
}

/** @test Verifies that a zero at the final byte of the struct is preserved */

void test_trailing_zero_payload(void) {
    struct TailZero { uint16_t val; uint8_t zero; } __attribute__((packed));
    tinylink::TinyLink<TailZero, LoopbackAdapter> tailLink(adapter);

    TailZero data = { 0xABCD, 0x00 };
    tailLink.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);

    while(adapter.available() > 0) tailLink.update();
    TEST_ASSERT_TRUE(tailLink.available());
    TEST_ASSERT_EQUAL_UINT8(0x00, tailLink.peek().zero);
}

/** @test Verifies that back-to-back packets with minimal spacing are both received */

void test_minimal_interframe_spacing(void) {
    TestPayload p = { 1, 1.0f };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);

    int count = 0;
    while(adapter.available() > 0) {
        link.update();
        if(link.available()) {
            count++;
            link.flush();
        }
    }
    TEST_ASSERT_EQUAL_INT(2, count);
}

/** @test Verifies that the PLAIN_SIZE remains within the safe uint8_t bounds (255) */

void test_protocol_mtu_limit(void) {
    // 3 (Header) + 64 (max Payload) + 2 (CRC) = 69
    TEST_ASSERT_LESS_THAN_UINT32(256, (3 + sizeof(TestPayload) + 2));
}

/** @test Verifies that the engine can handle packets with no inter-frame gap */

void test_zero_gap_stress(void) {
    TestPayload p = {10, 1.0f};
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);
    // Manually inject a second packet immediately
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);

    int count = 0;
    while(adapter.available() > 0) {
        link.update();
        if(link.available()) {
            count++;
            link.flush();
        }
    }
    TEST_ASSERT_EQUAL_INT(2, count);
}

/** @test Verifies that a 0x00 byte inside the payload is correctly handled by COBS */

void test_payload_zero_transparency(void) {
    TestPayload data = { 0x11002233, 0.0f }; // Contains two zeros in binary
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);

    while(adapter.available() > 0 && !link.available()) {
        link.update();
    }

    TEST_ASSERT_TRUE(link.available());
    TEST_ASSERT_EQUAL_UINT32(0x11002233, link.peek().uptime);
    TEST_ASSERT_EQUAL_FLOAT(0.0f, link.peek().value);
}

/** @test Verifies that multi-byte integers split across COBS blocks are reassembled correctly */

void test_split_integer_alignment(void) {
    // 0x11223344: We want the COBS 'pointer' to fall between 0x22 and 0x33
    TestPayload data = { 0x11223344, 1.0f };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);
    while(adapter.available() > 0) link.update();
    TEST_ASSERT_EQUAL_UINT32(0x11223344, link.peek().uptime);
}

/** @test Verifies Fletcher-16 accuracy on a high-contrast (min/max) bit pattern */

void test_fletcher_contrast_integrity(void) {
    struct Contrast { uint8_t a; uint8_t b; } __attribute__((packed));
    tinylink::TinyLink<Contrast, LoopbackAdapter> cLink(adapter);
    Contrast c = { 0x00, 0xFF };

    cLink.sendData('C', c);
    while(adapter.available() > 0) cLink.update();
    TEST_ASSERT_TRUE(cLink.available());
}

/** @test Verifies bit-transparency for negative values and maximum unsigned integers */

void test_signed_boundary_integrity(void) {
    TestPayload data = { 0xFFFFFFFF, -123.45f };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), data);
    while(adapter.available() > 0) link.update();

    TEST_ASSERT_EQUAL_UINT32(0xFFFFFFFF, link.peek().uptime);
    TEST_ASSERT_EQUAL_FLOAT(-123.45f, link.peek().value);
}

/** @test Verifies that Fletcher-16 handles payloads that result in a zero-sum correctly */

void test_zero_sum_integrity(void) {
    struct AllOnes { uint32_t a; uint32_t b; } __attribute__((packed));
    tinylink::TinyLink<AllOnes, LoopbackAdapter> aLink(adapter);
    AllOnes data = { 0x00, 0x00 }; // Often results in specific sum patterns

    aLink.sendData('D', data);
    while(adapter.available() > 0) aLink.update();
    TEST_ASSERT_TRUE(aLink.available());
}

/** @test Verifies Fletcher-16 mathematical correctness at the 255 modulo boundary */

void test_fletcher_modulo_boundary(void) {
    struct ModData { uint8_t a; uint8_t b; } __attribute__((packed));
    tinylink::TinyLink<ModData, LoopbackAdapter> mLink(adapter);

    // 0xFF (255) is the modulo identity for Fletcher.
    // Testing if 0x00 and 0xFF are treated correctly in the accumulator.
    ModData d = { 0xFF, 0xFF };
    mLink.sendData('M', d);
    while(adapter.available() > 0) mLink.update();
    TEST_ASSERT_TRUE(mLink.available());
}

/** @test Verifies that the engine handles a new frame delimiter immediately following a valid CRC */

void test_tight_frame_overlap(void) {
    TestPayload p = { 1, 1.0f };
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);
    // Manually inject a second delimiter to stress the sync logic
    uint8_t zero = 0x00;
    adapter.inject(&zero, 1);
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);

    int count = 0;
    while(adapter.available() > 0) {
        link.update();
        if(link.available()) { count++; link.flush(); }
    }
    TEST_ASSERT_EQUAL_INT(2, count);
}

/** @test Verifies that the struct has no "hidden" padding bytes by checking total size */

void test_struct_packing_integrity(void) {
    // uptime(4) + value(4) = 8. If sizeof is 9 or 12, packing failed.
    TEST_ASSERT_EQUAL_INT_MESSAGE(8, sizeof(TestPayload), "Struct padding detected! Packing failed.");
}

/** @test Verifies that the template handles the smallest possible primitive type */

void test_primitive_type_support(void) {
    tinylink::TinyLink<uint8_t, LoopbackAdapter> pLink(adapter);
    uint8_t val = 0xAB;
    pLink.sendData('P', val);
    while(adapter.available() > 0) pLink.update();
    TEST_ASSERT_EQUAL_UINT8(0xAB, pLink.peek());
}

/** @test Verifies Fletcher-16 stability with a high-bit-density (all 0xFF) payload */

void test_fletcher_overflow_stability(void) {
    TestPayload p; memset(&p, 0xFF, sizeof(p));
    link.sendData(static_cast<uint8_t>(tinylink::MessageType::Data), p);
    while(adapter.available() > 0) link.update();
    TEST_ASSERT_TRUE(link.available());
}

void register_application_tests(void) {
    RUN_TEST(test_cobs_loopback);
    RUN_TEST(test_cobs_zero_payload);
    RUN_TEST(test_type_filtering);
    RUN_TEST(test_float_extremes);
    RUN_TEST(test_minimum_payload);
    RUN_TEST(test_type_validation);
    RUN_TEST(test_leading_zero_payload);
    RUN_TEST(test_trailing_zero_payload);
    RUN_TEST(test_minimal_interframe_spacing);
    RUN_TEST(test_protocol_mtu_limit);
    RUN_TEST(test_zero_gap_stress);
    RUN_TEST(test_payload_zero_transparency);
    RUN_TEST(test_split_integer_alignment);
    RUN_TEST(test_fletcher_contrast_integrity);
    RUN_TEST(test_signed_boundary_integrity);
    RUN_TEST(test_zero_sum_integrity);
    RUN_TEST(test_fletcher_modulo_boundary);
    RUN_TEST(test_tight_frame_overlap);
    RUN_TEST(test_struct_packing_integrity);
    RUN_TEST(test_primitive_type_support);
    RUN_TEST(test_fletcher_overflow_stability);
}
